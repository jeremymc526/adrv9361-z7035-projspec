#
# When using the newer kernel we need to override the check
KERNEL_VERSION_SANITY_SKIP="1"
BB_STRICT_CHECKSUM="0"

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

